# Repository ben5049/switch-v5-hardware (continued)

## KiCad design pcbs/switch-main-v5/switch-main-v5.kicad_pcb (continued)

Schematic: 1000base-t1-phy.kicad_sch, 1000BASE-T1 PHY

Parts:
C2001, C2002, C2003, C2004, C2005, C2007, C2008, C2009, C2010, C2011, C2012, C2013, C2014: 100n; C_0402
C2006, C2015: 10u; C_0402
C2016: 10u; C_0402_1005Metric; not fitted
Q2001: DMN21D2UFB-7B; DMN21D2UFB7B; Mouser Part Number 621-DMN21D2UFB-7B
Q2002: DMP21D0UFB-7B; DMP21D0UFB7B; Mouser Part Number 621-DMP21D0UFB-7B
R2001: 10k; R_0402_1005Metric; not fitted
R2002: 4k7; R_0402
R2003: 4k7; R_0402_1005Metric; not fitted
R2004: 4k99; R_0402
R2005: 1k; R_0402
R2006: 47k; R_0402
TP2001: 1.5mm; TestPoint_Pad_D1.5mm
U2001: 88Q2112-A2-NYD2A000-P123; 88Q2112

Connections:
+0V9_3: C2010.1, C2012.1, C2014.1, U2001.17 (DVDD), U2001.43 (DVDD); also elsewhere on the board
+1V8_PHY: C2003.1, C2005.1, C2006.1, C2007.1, C2009.1, C2011.1, C2013.1, C2015.1, R2001.2, U2001.9 (AVDD18), U2001.24 (VDDO), U2001.33 (AVDD18), U2001.40 (VDDO); also elsewhere on the board
+3V3: C2002.1, C2004.1, U2001.6 (AVDD33); also elsewhere on the board
+3V3_AON: C2008.1, Q2002.2 (S), R2006.2, U2001.46 (VLPR); also elsewhere on the board
/CDNs/MDI1_IN.TRXN: U2001.5 (MDIN); also elsewhere on the board
/CDNs/MDI1_IN.TRXP: U2001.4 (MDIP); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/CLK_IN: C2001.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/GPIO: U2001.42 (GPIO/PHYAD2)
/PHYs/1000BASE-T1 PHY 1/INH_G: Q2001.1 (G), R2005.1
/PHYs/1000BASE-T1 PHY 1/INH_OUT: R2005.2, U2001.45 (INH)
/PHYs/1000BASE-T1 PHY 1/MDC: U2001.38 (MDC); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/MDIO: U2001.39 (MDIO); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/RSET: R2004.2, U2001.1 (RSET)
/PHYs/1000BASE-T1 PHY 1/XTAL_IN: C2001.1, U2001.12 (XTAL_IN)
/PHYs/1000BASE-T1 PHY 1/~INH: Q2001.3 (D), Q2002.1 (G), R2006.1
/PHYs/1000BASE-T PHY/~RST: U2001.36 (~RST); also elsewhere on the board
/PHYs/PWR_EN: Q2002.3 (D); also elsewhere on the board
/PHYs/WAKE: U2001.44 (WAKE_IN); also elsewhere on the board
/PHYs/xMII1.RX_CLK: U2001.23 (RCLK); also elsewhere on the board
/PHYs/xMII1.RX_CTL: R2002.2, U2001.22 (RXC); also elsewhere on the board
/PHYs/xMII1.RX_D0: U2001.21 (RXD0/PHYAD0); also elsewhere on the board
/PHYs/xMII1.RX_D1: U2001.20 (RXD1/PHYAD1); also elsewhere on the board
/PHYs/xMII1.RX_D2: U2001.19 (RXD2/MODE0); also elsewhere on the board
/PHYs/xMII1.RX_D3: U2001.18 (RXD3/MODE1); also elsewhere on the board
/PHYs/xMII1.TX_CLK: U2001.25 (TCLK); also elsewhere on the board
/PHYs/xMII1.TX_CTL: U2001.26 (TXC); also elsewhere on the board
/PHYs/xMII1.TX_D0: U2001.27 (TXD0); also elsewhere on the board
/PHYs/xMII1.TX_D1: U2001.28 (TXD1); also elsewhere on the board
/PHYs/xMII1.TX_D2: U2001.29 (TXD2); also elsewhere on the board
/PHYs/xMII1.TX_D3: U2001.30 (TXD3); also elsewhere on the board
/PHYs/~PHY_INT_1: U2001.37 (~INT); also elsewhere on the board
GND1: C2002.2, C2003.2, C2004.2, C2005.2, C2006.2, C2007.2, C2008.2, C2009.2, C2010.2, C2011.2, C2012.2, C2013.2, C2014.2, C2015.2, C2016.2, Q2001.2 (S), R2002.1, R2003.1, R2004.1, TP2001.1 (1_1), U2001.11 (VSSC), U2001.49 (VSS); also elsewhere on the board

Parts of its further copies:
C2101, C2102, C2103, C2104, C2105, C2107, C2108, C2109, C2110, C2111, C2112, C2113, C2114, C2201, C2202, C2203, C2204, C2205, C2207, C2208, C2209, C2210, C2211, C2212, C2213, C2214, C2301, C2302, C2303, C2304, C2305, C2307, C2308, C2309, C2310, C2311, C2312, C2313, C2314, C2401, C2402, C2403, C2404, C2405, C2407, C2408, C2409, C2410, C2411, C2412, C2413, C2414: 100n; C_0402
C2106, C2115, C2206, C2215, C2306, C2315, C2406, C2415: 10u; C_0402
Q2101, Q2201, Q2301, Q2401: DMN21D2UFB-7B; DMN21D2UFB7B; Mouser Part Number 621-DMN21D2UFB-7B
Q2102, Q2202, Q2302, Q2402: DMP21D0UFB-7B; DMP21D0UFB7B; Mouser Part Number 621-DMP21D0UFB-7B
R2102, R2202, R2302, R2402: 4k7; R_0402
R2104, R2204, R2304, R2404: 4k99; R_0402
R2105, R2205, R2305, R2405: 1k; R_0402
R2106, R2206, R2306, R2406: 47k; R_0402
TP2101, TP2201, TP2301, TP2401: 1.5mm; TestPoint_Pad_D1.5mm
U2101, U2201, U2301, U2401: 88Q2112-A2-NYD2A000-P123; 88Q2112

Connections of its further copies:
+0V9_1: C2310.1, C2312.1, C2314.1, C2410.1, C2412.1, C2414.1, U2301.17 (DVDD), U2301.43 (DVDD), U2401.17 (DVDD), U2401.43 (DVDD); also elsewhere on the board
+0V9_2: C2110.1, C2112.1, C2114.1, C2210.1, C2212.1, C2214.1, U2101.17 (DVDD), U2101.43 (DVDD), U2201.17 (DVDD), U2201.43 (DVDD); also elsewhere on the board
+1V8_PHY: C2103.1, C2105.1, C2106.1, C2107.1, C2109.1, C2111.1, C2113.1, C2115.1, C2203.1, C2205.1, C2206.1, C2207.1, C2209.1, C2211.1, C2213.1, C2215.1, C2303.1, C2305.1, C2306.1, C2307.1, C2309.1, C2311.1, C2313.1, C2315.1, C2403.1, C2405.1, C2406.1, C2407.1, C2409.1, C2411.1, C2413.1, C2415.1, U2101.9 (AVDD18), U2101.24 (VDDO), U2101.33 (AVDD18), U2101.40 (VDDO), U2201.9 (AVDD18), U2201.24 (VDDO), U2201.33 (AVDD18), U2201.40 (VDDO), U2301.9 (AVDD18), U2301.24 (VDDO), U2301.33 (AVDD18), U2301.40 (VDDO), U2401.9 (AVDD18), U2401.24 (VDDO), U2401.33 (AVDD18), U2401.40 (VDDO); also elsewhere on the board
+3V3: C2102.1, C2104.1, C2202.1, C2204.1, C2302.1, C2304.1, C2402.1, C2404.1, U2101.6 (AVDD33), U2201.6 (AVDD33), U2301.6 (AVDD33), U2401.6 (AVDD33); also elsewhere on the board
+3V3_AON: C2108.1, C2208.1, C2308.1, C2408.1, Q2102.2 (S), Q2202.2 (S), Q2302.2 (S), Q2402.2 (S), R2106.2, R2206.2, R2306.2, R2406.2, U2101.46 (VLPR), U2201.46 (VLPR), U2301.46 (VLPR), U2401.46 (VLPR); also elsewhere on the board
/CDNs & PoDL/MDI4_IN.TRXN: U2301.5 (MDIN); also elsewhere on the board
/CDNs & PoDL/MDI4_IN.TRXP: U2301.4 (MDIP); also elsewhere on the board
/CDNs & PoDL/MDI5_IN.TRXN: U2401.5 (MDIN); also elsewhere on the board
/CDNs & PoDL/MDI5_IN.TRXP: U2401.4 (MDIP); also elsewhere on the board
/CDNs/MDI2_IN.TRXN: U2101.5 (MDIN); also elsewhere on the board
/CDNs/MDI2_IN.TRXP: U2101.4 (MDIP); also elsewhere on the board
/CDNs/MDI3_IN.TRXN: U2201.5 (MDIN); also elsewhere on the board
/CDNs/MDI3_IN.TRXP: U2201.4 (MDIP); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/CLK_IN: C2101.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/GPIO: U2101.42 (GPIO/PHYAD2)
/PHYs/1000BASE-T1 PHY 2/INH_G: Q2101.1 (G), R2105.1
/PHYs/1000BASE-T1 PHY 2/INH_OUT: R2105.2, U2101.45 (INH)
/PHYs/1000BASE-T1 PHY 2/MDC: U2101.38 (MDC); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/MDIO: U2101.39 (MDIO); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/RSET: R2104.2, U2101.1 (RSET)
/PHYs/1000BASE-T1 PHY 2/XTAL_IN: C2101.1, U2101.12 (XTAL_IN)
/PHYs/1000BASE-T1 PHY 2/~INH: Q2101.3 (D), Q2102.1 (G), R2106.1
/PHYs/1000BASE-T1 PHY 3/CLK_IN: C2201.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 3/GPIO: U2201.42 (GPIO/PHYAD2)
/PHYs/1000BASE-T1 PHY 3/INH_G: Q2201.1 (G), R2205.1
/PHYs/1000BASE-T1 PHY 3/INH_OUT: R2205.2, U2201.45 (INH)
/PHYs/1000BASE-T1 PHY 3/MDC: U2201.38 (MDC); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 3/MDIO: U2201.39 (MDIO); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 3/RSET: R2204.2, U2201.1 (RSET)
/PHYs/1000BASE-T1 PHY 3/XTAL_IN: C2201.1, U2201.12 (XTAL_IN)
/PHYs/1000BASE-T1 PHY 3/~INH: Q2201.3 (D), Q2202.1 (G), R2206.1
/PHYs/1000BASE-T1 PHY 4/CLK_IN: C2301.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 4/GPIO: U2301.42 (GPIO/PHYAD2)
/PHYs/1000BASE-T1 PHY 4/INH_G: Q2301.1 (G), R2305.1
/PHYs/1000BASE-T1 PHY 4/INH_OUT: R2305.2, U2301.45 (INH)
/PHYs/1000BASE-T1 PHY 4/MDC: U2301.38 (MDC); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 4/MDIO: U2301.39 (MDIO); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 4/RSET: R2304.2, U2301.1 (RSET)
/PHYs/1000BASE-T1 PHY 4/XTAL_IN: C2301.1, U2301.12 (XTAL_IN)
/PHYs/1000BASE-T1 PHY 4/~INH: Q2301.3 (D), Q2302.1 (G), R2306.1
/PHYs/1000BASE-T1 PHY 5/CLK_IN: C2401.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 5/GPIO: U2401.42 (GPIO/PHYAD2)
/PHYs/1000BASE-T1 PHY 5/INH_G: Q2401.1 (G), R2405.1
/PHYs/1000BASE-T1 PHY 5/INH_OUT: R2405.2, U2401.45 (INH)
/PHYs/1000BASE-T1 PHY 5/MDC: U2401.38 (MDC); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 5/MDIO: U2401.39 (MDIO); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 5/RSET: R2404.2, U2401.1 (RSET)
/PHYs/1000BASE-T1 PHY 5/XTAL_IN: C2401.1, U2401.12 (XTAL_IN)
/PHYs/1000BASE-T1 PHY 5/~INH: Q2401.3 (D), Q2402.1 (G), R2406.1
/PHYs/1000BASE-T PHY/~RST: U2101.36 (~RST), U2201.36 (~RST), U2301.36 (~RST), U2401.36 (~RST); also elsewhere on the board
/PHYs/PWR_EN: Q2102.3 (D), Q2202.3 (D), Q2302.3 (D), Q2402.3 (D); also elsewhere on the board
/PHYs/WAKE: U2101.44 (WAKE_IN), U2201.44 (WAKE_IN), U2301.44 (WAKE_IN), U2401.44 (WAKE_IN); also elsewhere on the board
/PHYs/xMII2.RX_CLK: U2101.23 (RCLK); also elsewhere on the board
/PHYs/xMII2.RX_CTL: R2102.2, U2101.22 (RXC); also elsewhere on the board
/PHYs/xMII2.RX_D0: U2101.21 (RXD0/PHYAD0); also elsewhere on the board
/PHYs/xMII2.RX_D1: U2101.20 (RXD1/PHYAD1); also elsewhere on the board
/PHYs/xMII2.RX_D2: U2101.19 (RXD2/MODE0); also elsewhere on the board
/PHYs/xMII2.RX_D3: U2101.18 (RXD3/MODE1); also elsewhere on the board
/PHYs/xMII2.TX_CLK: U2101.25 (TCLK); also elsewhere on the board
/PHYs/xMII2.TX_CTL: U2101.26 (TXC); also elsewhere on the board
/PHYs/xMII2.TX_D0: U2101.27 (TXD0); also elsewhere on the board
/PHYs/xMII2.TX_D1: U2101.28 (TXD1); also elsewhere on the board
/PHYs/xMII2.TX_D2: U2101.29 (TXD2); also elsewhere on the board
/PHYs/xMII2.TX_D3: U2101.30 (TXD3); also elsewhere on the board
/PHYs/xMII3.RX_CLK: U2201.23 (RCLK); also elsewhere on the board
/PHYs/xMII3.RX_CTL: R2202.2, U2201.22 (RXC); also elsewhere on the board
/PHYs/xMII3.RX_D0: U2201.21 (RXD0/PHYAD0); also elsewhere on the board
/PHYs/xMII3.RX_D1: U2201.20 (RXD1/PHYAD1); also elsewhere on the board
/PHYs/xMII3.RX_D2: U2201.19 (RXD2/MODE0); also elsewhere on the board
/PHYs/xMII3.RX_D3: U2201.18 (RXD3/MODE1); also elsewhere on the board
/PHYs/xMII3.TX_CLK: U2201.25 (TCLK); also elsewhere on the board
/PHYs/xMII3.TX_CTL: U2201.26 (TXC); also elsewhere on the board
/PHYs/xMII3.TX_D0: U2201.27 (TXD0); also elsewhere on the board
/PHYs/xMII3.TX_D1: U2201.28 (TXD1); also elsewhere on the board
/PHYs/xMII3.TX_D2: U2201.29 (TXD2); also elsewhere on the board
/PHYs/xMII3.TX_D3: U2201.30 (TXD3); also elsewhere on the board
/PHYs/xMII4.RX_CLK: U2301.23 (RCLK); also elsewhere on the board
/PHYs/xMII4.RX_CTL: R2302.2, U2301.22 (RXC); also elsewhere on the board
/PHYs/xMII4.RX_D0: U2301.21 (RXD0/PHYAD0); also elsewhere on the board
/PHYs/xMII4.RX_D1: U2301.20 (RXD1/PHYAD1); also elsewhere on the board
/PHYs/xMII4.RX_D2: U2301.19 (RXD2/MODE0); also elsewhere on the board
/PHYs/xMII4.RX_D3: U2301.18 (RXD3/MODE1); also elsewhere on the board
/PHYs/xMII4.TX_CLK: U2301.25 (TCLK); also elsewhere on the board
/PHYs/xMII4.TX_CTL: U2301.26 (TXC); also elsewhere on the board
/PHYs/xMII4.TX_D0: U2301.27 (TXD0); also elsewhere on the board
/PHYs/xMII4.TX_D1: U2301.28 (TXD1); also elsewhere on the board
/PHYs/xMII4.TX_D2: U2301.29 (TXD2); also elsewhere on the board
/PHYs/xMII4.TX_D3: U2301.30 (TXD3); also elsewhere on the board
/PHYs/xMII5.RX_CLK: U2401.23 (RCLK); also elsewhere on the board
/PHYs/xMII5.RX_CTL: R2402.2, U2401.22 (RXC); also elsewhere on the board
/PHYs/xMII5.RX_D0: U2401.21 (RXD0/PHYAD0); also elsewhere on the board
/PHYs/xMII5.RX_D1: U2401.20 (RXD1/PHYAD1); also elsewhere on the board
/PHYs/xMII5.RX_D2: U2401.19 (RXD2/MODE0); also elsewhere on the board
/PHYs/xMII5.RX_D3: U2401.18 (RXD3/MODE1); also elsewhere on the board
/PHYs/xMII5.TX_CLK: U2401.25 (TCLK); also elsewhere on the board
/PHYs/xMII5.TX_CTL: U2401.26 (TXC); also elsewhere on the board
/PHYs/xMII5.TX_D0: U2401.27 (TXD0); also elsewhere on the board
/PHYs/xMII5.TX_D1: U2401.28 (TXD1); also elsewhere on the board
/PHYs/xMII5.TX_D2: U2401.29 (TXD2); also elsewhere on the board
/PHYs/xMII5.TX_D3: U2401.30 (TXD3); also elsewhere on the board
/PHYs/~PHY_INT_2: U2101.37 (~INT); also elsewhere on the board
/PHYs/~PHY_INT_3: U2201.37 (~INT); also elsewhere on the board
/PHYs/~PHY_INT_4: U2301.37 (~INT); also elsewhere on the board
/PHYs/~PHY_INT_5: U2401.37 (~INT); also elsewhere on the board
GND1: C2102.2, C2103.2, C2104.2, C2105.2, C2106.2, C2107.2, C2108.2, C2109.2, C2110.2, C2111.2, C2112.2, C2113.2, C2114.2, C2115.2, C2202.2, C2203.2, C2204.2, C2205.2, C2206.2, C2207.2, C2208.2, C2209.2, C2210.2, C2211.2, C2212.2, C2213.2, C2214.2, C2215.2, C2302.2, C2303.2, C2304.2, C2305.2, C2306.2, C2307.2, C2308.2, C2309.2, C2310.2, C2311.2, C2312.2, C2313.2, C2314.2, C2315.2, C2402.2, C2403.2, C2404.2, C2405.2, C2406.2, C2407.2, C2408.2, C2409.2, C2410.2, C2411.2, C2412.2, C2413.2, C2414.2, C2415.2, Q2101.2 (S), Q2201.2 (S), Q2301.2 (S), Q2401.2 (S), R2102.1, R2104.1, R2202.1, R2204.1, R2302.1, R2304.1, R2402.1, R2404.1, TP2101.1 (1_1), TP2201.1 (1_1), TP2301.1 (1_1), TP2401.1 (1_1), U2101.11 (VSSC), U2101.49 (VSS), U2201.11 (VSSC), U2201.49 (VSS), U2301.11 (VSSC), U2301.49 (VSS), U2401.11 (VSSC), U2401.49 (VSS); also elsewhere on the board

Notes on the sheet:
AVDD18: 145mA Typ 152mA Max
RSET Must be 1% tolerance
No pulldowns on PHYADx means address will be 0x00.
AVDD33: 25mA Typ 27mA Max
VDDO: 18.6mA Typ
DVDD: 202mA Typ 359mA Max
This INH circuit is non-standard, and requires testing.
MODE[1:0] = 0x00 means the PHY will start as a 100BASE-T1 master, 0x01 means 100BASE-T1 slave.
Maximum allowed noise on any supply is 50mV peak to peak
Internal GPIO pullups needed for ~{INT}.
Pulldown on RXC means RGMII is selected as the interface.

Schematic: 10base-t1s-phy.kicad_sch, 10BASE-T1S PHY

Parts:
C2501, C2502, C2503: 10u; C_0402
C2504, C2505, C2506, C2510: 100n; C_0402
C2507, C2508, C2509, C2511: 10n; C_0402
R2501, R2502, R2504, R2505, R2506, R2507: 10k; R_0402
R2503: 10k; R_0402_1005Metric; not fitted
R2508: 12k4; R_0402
U2501: LAN8671C2-E_U3B; QFN50P400X400X100-25N-D; Mouser Part Number 579-LAN8671C2-E/U3B

Connections:
+3V3: C2501.1, C2502.1, C2504.1, C2505.1, C2507.1, C2508.1, C2510.1, C2511.1, R2501.1, R2503.1, R2505.1, U2501.6 (VDDP_1), U2501.13 (VDDP_2), U2501.22 (VDDA); also elsewhere on the board
+3V3_AON: C2503.1, C2506.1, C2509.1, U2501.18 (VDDAU); also elsewhere on the board
/CDNs & PoDL/MDI6_IN.TRXN: U2501.24 (TRXN); also elsewhere on the board
/CDNs & PoDL/MDI6_IN.TRXP: U2501.23 (TRXP); also elsewhere on the board
/PHYs/10BASE-T1S PHY/PTP_TS: U2501.7 (GPIO0)
/PHYs/10BASE-T1S PHY/RBIAS: R2508.1, U2501.19 (RBIAS)
/PHYs/10BASE-T1S PHY/WAKE_OUT: U2501.17 (WAKE_OUT)
/PHYs/MDC: U2501.9 (MDC); also elsewhere on the board
/PHYs/MDIO: U2501.10 (MDIO); also elsewhere on the board
/PHYs/PWR_EN: U2501.2 (INH); also elsewhere on the board
/PHYs/WAKE: U2501.1 (WAKE_IN); also elsewhere on the board
/PHYs/xMII6.RX_CRS_DV: R2507.1, U2501.14 (CRSDV/PHYAD1); also elsewhere on the board
/PHYs/xMII6.RX_D0: R2504.1, U2501.11 (RXD0/PHYAD2); also elsewhere on the board
/PHYs/xMII6.RX_D1: R2505.2, U2501.12 (RXD1/PHYAD3); also elsewhere on the board
/PHYs/xMII6.RX_ER: R2506.1, U2501.15 (RXER/PHYAD0); also elsewhere on the board
/PHYs/xMII6.TX_D0: U2501.4 (TXD0); also elsewhere on the board
/PHYs/xMII6.TX_D1: U2501.3 (TXD1); also elsewhere on the board
/PHYs/xMII6.TX_EN: R2502.1, U2501.5 (TXEN); also elsewhere on the board
/PHYs/xMII6_REF_CLK: U2501.20 (REFCLKIN); also elsewhere on the board
/PHYs/~PHY_INT_6: R2501.2, U2501.16 (IRQ_N); also elsewhere on the board
/PHYs/~RST: R2503.2, U2501.8 (RESET_N); also elsewhere on the board
GND1: C2501.2, C2502.2, C2503.2, C2504.2, C2505.2, C2506.2, C2507.2, C2508.2, C2509.2, C2510.2, C2511.2, R2502.2, R2504.2, R2506.2, R2507.2, R2508.2, U2501.25 (VSS); also elsewhere on the board

Notes on the sheet:
VDDA: 34mA Typ 41mA Max
PHY_ADDR = 0x0008
VDDP: 4mA Typ
The first time VDDAU is powered up it asserts INH (HIGH).
VDDAU: 0.57mA Typ
RBIAS must be +-1%

Schematic: phy-clock-control.kicad_sch, SMI Level Shifting

Parts:
C1801, C1802: 1u; C_0402
C1803, C1804, C1805: 100n; C_0402
NT1801, NT1802, NT1803, NT1804, NT1805, NT1806, NT1807: Net Tie 2; NetTie-2_SMD_Pad0.15mm
Q1801, Q1802, Q1803: DMN21D2UFB-7B; DMN21D2UFB7B; Mouser Part Number 621-DMN21D2UFB-7B
R1801, R1802, R1803, R1804: 1k5; R_0402
R1805: 47k; R_0402
R1806, R1807, R1808, R1810, R1812, R1813: 22R; R_0402
R1809, R1811: 22R; R_0402_1005Metric; not fitted
R1814, R1815, R1816, R1817, R1818: 22k; R_0402
R1819, R1820: 10k; R_0402
TP1801, TP1802, TP1803, TP1804: 1.5mm; TestPoint_Pad_D1.5mm
U1801, U1802: LMK1C1104DQFR; SON50P200X200X80-8N; Mouser Part Number 595-LMK1C1104DQFR
U1803: NX3L4051HRZ; QFN50P300X300X50-17N-D; Mouser Part Number 771-NX3L4051HRZ

Connections:
+1V8: C1801.1, C1802.1, C1803.1, C1804.1, R1805.2, U1801.6 (VDD), U1802.6 (VDD); also elsewhere on the board
+1V8_PHY: C1805.1, Q1801.1 (G), Q1802.1 (G), Q1803.1 (G), R1803.2, R1804.2, R1820.2, U1803.14 (VCC); also elsewhere on the board
+3V3: R1801.2, R1802.2, R1819.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/CLK_IN: R1812.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/MDC: NT1803.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 1/MDIO: R1818.2, U1803.3 (Y5); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/CLK_IN: R1813.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/MDC: NT1804.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 2/MDIO: R1817.2, U1803.15 (Y4); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 3/CLK_IN: R1806.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 3/MDC: NT1805.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 3/MDIO: R1815.2, U1803.13 (Y2); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 4/CLK_IN: R1808.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 4/MDC: NT1806.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 4/MDIO: R1814.2, U1803.12 (Y1); also elsewhere on the board
/PHYs/1000BASE-T1 PHY 5/CLK_IN: R1807.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 5/MDC: NT1807.2; also elsewhere on the board
/PHYs/1000BASE-T1 PHY 5/MDIO: R1816.2, U1803.10 (Y3); also elsewhere on the board
/PHYs/1000BASE-T PHY/CLK_IN: R1810.2; also elsewhere on the board
/PHYs/1000BASE-T PHY/SMI.MDC: NT1801.2; also elsewhere on the board
/PHYs/1000BASE-T PHY/SMI.MDIO: NT1802.2; also elsewhere on the board
/PHYs/1000BASE-T PHY/~RST: Q1803.2 (S), R1820.1; also elsewhere on the board
/PHYs/CLK_EN: R1805.1, U1801.2 (1G), U1802.2 (1G); also elsewhere on the board
/PHYs/CLK_IN1: U1801.1 (CLKIN); also elsewhere on the board
/PHYs/CLK_IN2: U1802.1 (CLKIN); also elsewhere on the board
/PHYs/MDC: Q1801.3 (D), R1801.1; also elsewhere on the board
/PHYs/MDIO: Q1802.3 (D), R1802.1; also elsewhere on the board
/PHYs/PHY Clock & Control/MDC_1V8: NT1801.1, NT1803.1, NT1804.1, NT1805.1, NT1806.1, NT1807.1, Q1801.2 (S), R1803.1, TP1801.1 (1_1)
/PHYs/PHY Clock & Control/MDIO_1V8: NT1802.1, Q1802.2 (S), R1804.1, TP1802.1 (1_1), U1803.1 (Z)
/PHYs/PHY Clock & Control/Y0A: R1806.1, U1801.3 (Y0)
/PHYs/PHY Clock & Control/Y0B: R1810.1, U1802.3 (Y0)
/PHYs/PHY Clock & Control/Y1A: R1807.1, U1801.8 (Y1)
/PHYs/PHY Clock & Control/Y1B: R1811.1, U1802.8 (Y1)
/PHYs/PHY Clock & Control/Y2A: R1808.1, U1801.5 (Y2)
/PHYs/PHY Clock & Control/Y2B: R1812.1, U1802.5 (Y2)
/PHYs/PHY Clock & Control/Y3A: R1809.1, U1801.7 (Y3)
/PHYs/PHY Clock & Control/Y3B: R1813.1, U1802.7 (Y3)
/PHYs/SMI_SEL1: U1803.9 (S1); also elsewhere on the board
/PHYs/SMI_SEL2: U1803.8 (S2); also elsewhere on the board
/PHYs/SMI_SEL3: U1803.7 (S3); also elsewhere on the board
/PHYs/~RST: Q1803.3 (D), R1819.1; also elsewhere on the board
GND1: C1801.2, C1802.2, C1803.2, C1804.2, C1805.2, R1814.1, R1815.1, R1816.1, R1817.1, R1818.1, TP1803.1 (1_1), TP1804.1 (1_1), U1801.4 (GND), U1802.4 (GND), U1803.4 (~E), U1803.6 (GND), U1803.17 (EP); also elsewhere on the board

Notes on the sheet:
Source termination (place close to buffer)
The 1000BASE-T1 PHYs operate at a 1V8 logic level (to save RGMII power), but the SMI and ~{RST} pins operate at a 3V3 logic level. Level shifting is used to allow communication.
Due to a lack of strapping pins, the PHY addresses are duplicated and a MUX must be used to address them. Only the MDIO line is MUX'd and so the unselected PHYs will receive all 0s which means the preamble can never occur so no transactions are possible. Firmware must ensure SMI_SEL pins are stable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

Schematic: 1000base-t-phy.kicad_sch, PHY

Parts:
C1901, C1904, C1908: 10u; C_0402
C1902, C1903, C1905, C1906, C1907, C1909, C1911, C1912, C1914: 1u; C_0402
C1910, C1913, C1915, C1916, C1917, C1918, C1919, C1920, C1921: 100n; C_0402
C1922, C1923, C1924: 10n; C_0402
R1901: 10k; R_0402_1005Metric; not fitted
R1902: 5k76; R_0402
R1903, R1908: 2k49; R_0402
R1904, R1907: 1k5; R_0402_1005Metric; not fitted
R1905: Rhi; R_0402_1005Metric; not fitted
R1906, R1909: Rlo; R_0402_1005Metric; not fitted
R1910: 11k; R_0402
U1901: DP83867IRRGZR; QFN50P700X700X100-49N-D; Mouser Part Number 595-DP83867IRRGZR

Connections:
+1V0: C1901.1, C1902.2, C1903.2, C1905.2, C1907.2, C1910.2, C1913.2, C1916.2, C1919.2, C1922.2, U1901.6 (VDD1P0_1), U1901.24 (VDD1P0_2), U1901.31 (VDD1P0_3), U1901.42 (VDD1P0_4); also elsewhere on the board
+1V8: C1904.1, C1906.2, C1909.2, C1912.2, C1915.2, C1918.2, C1921.2, C1924.2, R1901.1, R1902.1, R1904.1, R1905.1, R1907.1, R1908.1, U1901.19 (VDDIO_1), U1901.30 (VDDIO_2), U1901.41 (VDDIO_3); also elsewhere on the board
+2V5: C1908.1, C1911.2, C1914.2, C1917.2, C1920.2, C1923.2, U1901.3 (VDDA2P5_1), U1901.9 (VDDA2P5_2); also elsewhere on the board
/Ethernet Connectors/LED.G: U1901.47 (LED_0); also elsewhere on the board
/Ethernet Connectors/LED.Y: U1901.45 (LED_2); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_A_N: U1901.2 (TD_M_A); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_A_P: U1901.1 (TD_P_A); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_B_N: U1901.5 (TD_M_B); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_B_P: U1901.4 (TD_P_B); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_C_N: U1901.8 (TD_M_C); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_C_P: U1901.7 (TD_P_C); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_D_N: U1901.11 (TD_M_D); also elsewhere on the board
/Ethernet Connectors/MDI0.TD_D_P: U1901.10 (TD_P_D); also elsewhere on the board
/PHYs/1000BASE-T PHY/CLK_IN: U1901.15 (X_I); also elsewhere on the board
/PHYs/1000BASE-T PHY/GPIO_0: U1901.39 (GPIO_0)
/PHYs/1000BASE-T PHY/RBIAS: R1910.1, U1901.12 (RBIAS)
/PHYs/1000BASE-T PHY/SMI.MDC: R1907.2, U1901.16 (MDC); also elsewhere on the board
/PHYs/1000BASE-T PHY/SMI.MDIO: R1904.2, U1901.17 (MDIO); also elsewhere on the board
/PHYs/1000BASE-T PHY/~RST: R1901.2, U1901.43 (RESET_N); also elsewhere on the board
/PHYs/xMII0.RX_CLK: U1901.32 (RX_CLK); also elsewhere on the board
/PHYs/xMII0.RX_CTL: R1902.2, R1903.1, U1901.38 (RX_CTRL); also elsewhere on the board
/PHYs/xMII0.RX_D0: R1908.2, R1909.1, U1901.33 (RX_D0); also elsewhere on the board
/PHYs/xMII0.RX_D1: U1901.34 (RX_D1); also elsewhere on the board
/PHYs/xMII0.RX_D2: R1905.2, R1906.1, U1901.35 (RX_D2); also elsewhere on the board
/PHYs/xMII0.RX_D3: U1901.36 (RX_D3); also elsewhere on the board
/PHYs/xMII0.TX_CLK: U1901.29 (GTX_CLK); also elsewhere on the board
/PHYs/xMII0.TX_CTL: U1901.37 (TX_CTRL); also elsewhere on the board
/PHYs/xMII0.TX_D0: U1901.28 (TX_D0); also elsewhere on the board
/PHYs/xMII0.TX_D1: U1901.27 (TX_D1); also elsewhere on the board
/PHYs/xMII0.TX_D2: U1901.26 (TX_D2); also elsewhere on the board
/PHYs/xMII0.TX_D3: U1901.25 (TX_D3); also elsewhere on the board
/PHYs/~PHY_INT_0: U1901.44 (INT/PWDN); also elsewhere on the board
GND1: C1901.2, C1902.1, C1903.1, C1904.2, C1905.1, C1906.1, C1907.1, C1908.2, C1909.1, C1910.1, C1911.1, C1912.1, C1913.1, C1914.1, C1915.1, C1916.1, C1917.1, C1918.1, C1919.1, C1920.1, C1921.1, C1922.1, C1923.1, C1924.1, R1903.2, R1906.2, R1909.2, R1910.2, U1901.49 (GND); also elsewhere on the board

Notes on the sheet:
PHY_ADD = 0x03
RX_D0 = PHY_ADD[0:1] RX_D2 = PHY_ADD[2:3] RX_CTRL = Autoneg Disable
RBIAS resistor must be +-1%

Schematic: power-regulators-isolated.kicad_sch, Regulators (Connector Side)

Parts:
C1301: 10u; C_0805; Voltage 50V
C1302, C1303, C1304, C1306, C1311: 1u; C_0402
C1305: 100n; C_0402
C1307, C1308, C1309, C1310, C1312: 4u7; C_0402
L1301: 74438323047; L_Wurth_WE-MAPI-2510; Part Number 74438323047
R1301: 180k; R_0402
R1302: 33k; R_0402
TP1301, TP1302: 1.5mm; TestPoint_Pad_D1.5mm
U1301: TPS7B8133QDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS7B8133QDRVRQ1
U1302: MAX20075DATCA/V+; SON50P300X300X80-13N
U1303: NCP508MT25TBG

Connections:
+2V5_ISO: C1311.1, U1303.1 (VOUT); also elsewhere on the board
+3V3_ISO: C1304.1, C1306.1, TP1301.1 (1_1), U1301.6 (OUT), U1303.6 (VIN); also elsewhere on the board
+6V5_ISO: C1302.1, C1307.1, C1308.1, C1309.1, C1310.1, C1312.1, L1301.2 (w2), R1301.2, TP1302.1 (1_1), U1301.1 (IN), U1301.2 (EN), U1302.9 (OUT); also elsewhere on the board
+VIN_ISO: C1301.1, U1302.2 (EN), U1302.4 (SUP); also elsewhere on the board
/Power/2V5_ISO_EN: U1303.4 (EN); also elsewhere on the board
/Power/3V3_ISO_MODE: U1302.11 (SYNC); also elsewhere on the board
/Power/Regulators (Isolated)/BIAS: C1303.1, U1302.1 (SPS), U1302.10 (BIAS)
/Power/Regulators (Isolated)/BST: C1305.1, U1302.3 (BST)
/Power/Regulators (Isolated)/FB: R1301.1, R1302.2, U1302.8 (FB)
/Power/Regulators (Isolated)/LX: C1305.2, L1301.1, U1302.5 (LX)
GND2: C1301.2, C1302.2, C1303.2, C1304.2, C1306.2, C1307.2, C1308.2, C1309.2, C1310.2, C1311.2, C1312.2, R1302.1, U1301.3 (GND), U1301.4 (GND), U1301.7 (EP), U1302.6 (PGND), U1302.7 (AGND), U1302.13 (GND), U1303.3 (GND); also elsewhere on the board

Notes on the sheet:
2V5 Regulator
6V5 Regulator
3V3 Regulator
SYNC (MODE): - HIGH = FPWM (low ripple) - LOW = Skip (low power) (default)
Use high quality, low ESR (<50mΩ) capacitors such as GRM155R61A475ME02
Vout = 6.45V [6.25V ... 6.66V]

Schematic: power-3v3-regulators.kicad_sch, 3V3 Regulators (PHY Side)

Parts:
C401, C402: 10u; C_0805; Voltage 50V
C403, C405: 1u; C_0402
C404: 1u; C_0402; Voltage 50V
C406, C407, C408, C409, C410, C411, C412, C413, C414, C415: 4u7; C_0402
L401: 74479335329222; L_Wurth_WE-PMFI-353220; Part Number 74479335329222
R401, R402: 10k; R_0402
R403: 100k; R_0402
TP401, TP402, TP403: 1.5mm; TestPoint_Pad_D1.5mm
U401: LMQ66430MC3RXBRQ1; LMQ664x0
U402: TPS7B8133QDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS7B8133QDRVRQ1
U403: TPS2116DRL; SOTFL50P160X60-8N

Connections:
+3V3: C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C415.1, L401.2, R403.2, TP402.1 (1_1), TP403.1 (1_1), U401.11 (VOUT/FB), U403.3 (VIN1), U403.5 (MODE); also elsewhere on the board
+3V3_AON: TP401.1 (1_1), U403.2 (VOUT), U403.7 (VOUT); also elsewhere on the board
+VIN: C401.1, C402.1, C404.1, U401.3 (VIN), U402.1 (IN), U402.2 (EN); also elsewhere on the board
/PHYs/PWR_EN: R401.1, U401.1 (EN/UVLO); also elsewhere on the board
/Power/3V3 Regulators/3V3_AON_RAW: C405.1, U402.6 (OUT), U403.6 (VIN2)
/Power/3V3 Regulators/3V3_PG: R403.1, U401.14 (PG), U403.4 (PR1)
/Power/3V3 Regulators/SW: L401.1, U401.7 (SW)
/Power/3V3 Regulators/VCC: C403.1, U401.10 (VCC)
/Power/3V3_AON_ST: U403.8 (ST); also elsewhere on the board
/Power/3V3_MODE: R402.1, U401.13 (MODE/SYNC); also elsewhere on the board
GND1: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, R401.2, R402.2, U401.6 (PGND), U401.15 (GND/DAP), U402.3 (GND), U402.4 (GND), U402.7 (EP), U403.1 (GND); also elsewhere on the board

Notes on the sheet:
3V3 Always on supply
3V3 Main Regulator
PR1 > 1V => VOUT = VIN1 PR1 < 1V => VOUT = VIN2
EN is set high by PHY INH outputs
Use high quality, low ESR (<50mΩ) capacitors such as GRM155R61A475ME02
3A Max
3V3_AON switchover to use most efficient supply.
MODE is auto by default. Setting MODE high means a lower output ripple which is necessary for the ethernet PHYs.
3V3_AON_ST Needs an MCU internal pullup
150mA Max

Schematic: power-in.kicad_sch, Power In (PHY Side)

Parts:
C301: 100n; C_0603; Voltage 100V
D301: SZESD7241N2T5G; SZESD7462N2T5G; Mouser Part Number 863-SZESD7241N2T5G
J301: MKXS1-1 Power Input; 10132797-031100LF
R301: 120k; R_0402
R302: 10k; R_0402
R303: 4k7; R_0402
R304: 22k; R_0402
R305, R306, R307: 100k; R_0402
R308: 5k6; R_0402
U301: TVS3301DRBR; SON65P300X300X100-9N-D
U302: TPS26600RHFR; QFN50P400X500X100-25N-D; Mouser Part Number 595-TPS26601RHFR

Connections:
+VIN: R307.2, U302.23 (OUT_1), U302.24 (OUT_2); also elsewhere on the board
/Power/Power In/EFUSE_IMON: R305.2, R306.2, U302.18 (IMON)
/Power/Power In/ILIM: R304.2, U302.19 (ILIM)
/Power/Power In/OVP: R302.2, R303.1, U302.12 (OVP)
/Power/Power In/RTN: R303.2, R304.1, R305.1, U302.15 (RTN), U302.25 (EP)
/Power/Power In/UVLO: R301.2, R302.1, U302.10 (UVLO)
/Power/Power In/VIN_RAW: C301.2, D301.2 (A2), J301.1 (V+), J301.2 (V+), J301.3 (V+), J301.4 (V+), J301.5 (V+), J301.6 (V+), J301.25 (V+), J301.26 (V+), J301.27 (V+), J301.28 (V+), J301.29 (V+), J301.30 (V+), R301.1, U301.1 (IN), U301.2 (IN), U301.3 (IN), U301.4 (IN), U302.8 (IN_1), U302.9 (IN_2)
/Power/Power In/~FLT: U302.22 (~FLT)
/Power/VIN_IMON: R306.1; also elsewhere on the board
/Power/VIN_VMON: R307.1, R308.2; also elsewhere on the board
GND1: C301.1, D301.1 (A1), J301.7 (V-), J301.8 (V-), J301.9 (V-), J301.10 (V-), J301.11 (V-), J301.12 (V-), J301.19 (V-), J301.20 (V-), J301.21 (V-), J301.22 (V-), J301.23 (V-), J301.24 (V-), J301.MP1 (MP), J301.MP2 (MP), R308.1, U301.5 (GND), U301.6 (GND), U301.7 (GND), U301.8 (GND), U302.17 (GND); also elsewhere on the board

Notes on the sheet:
ESD Protection
Surge Protection
UVLO = 10.9V OVP = 34.1V
I_{OUT} = V_{IMON} / 7.84
VMON = VIN / 18.857 The 150mΩ eFuse resistance should be taken into account when calculating input power.
R_{ILIM} = 22kΩ ∴ I_{LIM} = 12 / 22 = 545mA
eFuse
TPS26600 has auto-retry when a fault occurs.

Schematic: power-in-isolated.kicad_sch, Power In (Connector Side)

Parts:
C1201: 100n; C_0603; Voltage 100V
D1201: SZESD7241N2T5G; SZESD7462N2T5G; Mouser Part Number 863-SZESD7241N2T5G
J1201: MKXS1-1 Power Input; 10132797-031100LF
R1201: 120k; R_0402
R1202: 10k; R_0402
R1203: 4k7; R_0402
R1204, R1208: 5k6; R_0402
R1205: 15k; R_0402
R1206, R1207: 100k; R_0402
U1201: TVS3301DRBR; SON65P300X300X100-9N-D
U1202: TPS26600RHFR; QFN50P400X500X100-25N-D; Mouser Part Number 595-TPS26601RHFR

Connections:
+VIN_ISO: R1207.2, U1202.23 (OUT_1), U1202.24 (OUT_2); also elsewhere on the board
/Power/Power In (Isolated)/EFUSE_IMON: R1205.2, R1206.2, U1202.18 (IMON)
/Power/Power In (Isolated)/ILIM: R1204.2, U1202.19 (ILIM)
/Power/Power In (Isolated)/OVP: R1202.2, R1203.1, U1202.12 (OVP)
/Power/Power In (Isolated)/RTN: R1203.2, R1204.1, R1205.1, U1202.15 (RTN), U1202.25 (EP)
/Power/Power In (Isolated)/UVLO: R1201.2, R1202.1, U1202.10 (UVLO)
/Power/Power In (Isolated)/VIN_RAW: C1201.2, D1201.2 (A2), J1201.1 (V+), J1201.2 (V+), J1201.3 (V+), J1201.4 (V+), J1201.5 (V+), J1201.6 (V+), J1201.25 (V+), J1201.26 (V+), J1201.27 (V+), J1201.28 (V+), J1201.29 (V+), J1201.30 (V+), R1201.1, U1201.1 (IN), U1201.2 (IN), U1201.3 (IN), U1201.4 (IN), U1202.8 (IN_1), U1202.9 (IN_2)
/Power/Power In (Isolated)/~FLT: U1202.22 (~FLT)
/Power/VIN_ISO_IMON: R1206.1; also elsewhere on the board
/Power/VIN_ISO_VMON: R1207.1, R1208.2; also elsewhere on the board
GND2: C1201.1, D1201.1 (A1), J1201.7 (V-), J1201.8 (V-), J1201.9 (V-), J1201.10 (V-), J1201.11 (V-), J1201.12 (V-), J1201.19 (V-), J1201.20 (V-), J1201.21 (V-), J1201.22 (V-), J1201.23 (V-), J1201.24 (V-), J1201.MP1 (MP), J1201.MP2 (MP), R1208.1, U1201.5 (GND), U1201.6 (GND), U1201.7 (GND), U1201.8 (GND), U1202.17 (GND); also elsewhere on the board

Notes on the sheet:
eFuse
Surge Protection
I_{OUT} = V_{IMON} / 1.125 Can be done with integers: I_{OUT} = (V_{IMON} << 3) / 9
UVLO = 10.9V OVP = 34.1V
VMON = VIN_ISO / 18.857 The 150mΩ eFuse resistance should be taken into account when calculating input power.
TPS26600 has auto-retry when a fault occurs.
R_{ILIM} = 5k6Ω ∴ I_{LIM} = 2143mA
ESD Protection

Schematic: power-ethernet.kicad_sch, Ethernet Power (PHY Side)

Parts:
C501, C502, C503, C504: 1u; C_0402
C505: 4u7; C_0402
TP501: 1.5mm; TestPoint_Pad_D1.5mm
U501: TPS7A2025PDQNR; DQN0004A-MFG
U502: TPS7A1409PDRVR; SON65P200X200X80-7N

Connections:
+0V9_3: C505.1, TP501.1 (1_1), U502.1 (OUT), U502.2 (SENSE); also elsewhere on the board
+1V0: C503.1, U502.3 (EN), U502.6 (IN); also elsewhere on the board
+2V5: C502.1, U501.1 (OUT); also elsewhere on the board
+3V3: C501.1, C504.1, U501.3 (EN), U501.4 (IN), U502.4 (BIAS); also elsewhere on the board
GND1: C501.2, C502.2, C503.2, C504.2, C505.2, U501.2 (GND), U501.5 (EP), U502.5 (GND), U502.7 (EP); also elsewhere on the board

Schematic: 1v8_buck_converter.kicad_sch

Parts:
C601, C602, C604, C605, C606: 4u7; C_0402
C603: 22p; C_0402
L601: 78438313015; L_Wurth_WE-MAIA-1610; Part Number 78438313015
R601: 360k; R_0402
R602: 180k; R_0402
TP601: 1.5mm; TestPoint_Pad_D1.5mm
U601: TPS62290TDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS62290TDRVRQ1

Connections:
+1V8: C603.1, C604.1, C605.1, C606.1, L601.2, R601.1, TP601.1 (1_1); also elsewhere on the board
+3V3: C601.1, C602.1, U601.2 (MODE), U601.4 (EN), U601.5 (VIN); also elsewhere on the board
/Power/Ethernet Power/1V8 Buck Converter/FB: C603.2, R601.2, R602.1, U601.3 (FB)
/Power/Ethernet Power/1V8 Buck Converter/SW: L601.1, U601.1 (SW)
GND1: C601.2, C602.2, C604.2, C605.2, C606.2, R602.2, U601.6 (GND), U601.7 (EP); also elsewhere on the board

Parts of its further copies:
C701, C702, C704, C705, C706: 4u7; C_0402
C703: 22p; C_0402
L701: 78438313015; L_Wurth_WE-MAIA-1610; Part Number 78438313015
R701: 360k; R_0402
R702: 180k; R_0402
TP701: 1.5mm; TestPoint_Pad_D1.5mm
U701: TPS62290TDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS62290TDRVRQ1

Connections of its further copies:
+1V8_PHY: C703.1, C704.1, C705.1, C706.1, L701.2, R701.1, TP701.1 (1_1); also elsewhere on the board
+3V3: C701.1, C702.1, U701.2 (MODE), U701.4 (EN), U701.5 (VIN); also elsewhere on the board
/Power/Ethernet Power/1V8_PHY Buck Converter/FB: C703.2, R701.2, R702.1, U701.3 (FB)
/Power/Ethernet Power/1V8_PHY Buck Converter/SW: L701.1, U701.1 (SW)
GND1: C701.2, C702.2, C704.2, C705.2, C706.2, R702.2, U701.6 (GND), U701.7 (EP); also elsewhere on the board

Notes on the sheet:
1V8 Regulator
Use high quality, low ESR (<50mΩ) capacitors such as GRM155R61A475ME02

Schematic: 1v0_buck_converter.kicad_sch

Parts:
C901, C902, C904, C905, C906: 4u7; C_0402
C903: 22p; C_0402
L901: 78438313015; L_Wurth_WE-MAIA-1610; Part Number 78438313015
R901: 120k; R_0402
R902: 180k; R_0402
TP901: 1.5mm; TestPoint_Pad_D1.5mm
U901: TPS62290TDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS62290TDRVRQ1

Connections:
+1V0: C903.1, C904.1, C905.1, C906.1, L901.2, R901.1, TP901.1 (1_1); also elsewhere on the board
+3V3: C901.1, C902.1, U901.2 (MODE), U901.4 (EN), U901.5 (VIN); also elsewhere on the board
/Power/Ethernet Power/1V0 Buck Converter/FB: C903.2, R901.2, R902.1, U901.3 (FB)
/Power/Ethernet Power/1V0 Buck Converter/SW: L901.1, U901.1 (SW)
GND1: C901.2, C902.2, C904.2, C905.2, C906.2, R902.2, U901.6 (GND), U901.7 (EP); also elsewhere on the board

Notes on the sheet:
1V0 Regulator
MODE >=1.0V means FPWM mode (necessary for PHY ripple specs)
Use high quality, low ESR (<50mΩ) capacitors such as GRM155R61A475ME02

Schematic: 0v9_buck_converter.kicad_sch

Parts:
C1001, C1002, C1004, C1005, C1006: 4u7; C_0402
C1003: 22p; C_0402
L1001: 78438313015; L_Wurth_WE-MAIA-1610; Part Number 78438313015
R1001: 180k; R_0402
R1002: 360k; R_0402
TP1001: 1.5mm; TestPoint_Pad_D1.5mm
U1001: TPS62290TDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS62290TDRVRQ1

Connections:
+0V9_1: C1003.1, C1004.1, C1005.1, C1006.1, L1001.2, R1001.1, TP1001.1 (1_1); also elsewhere on the board
+3V3: C1001.1, C1002.1, U1001.2 (MODE), U1001.4 (EN), U1001.5 (VIN); also elsewhere on the board
/Power/Ethernet Power/0V9_1 Buck Converter/FB: C1003.2, R1001.2, R1002.1, U1001.3 (FB)
/Power/Ethernet Power/0V9_1 Buck Converter/SW: L1001.1, U1001.1 (SW)
GND1: C1001.2, C1002.2, C1004.2, C1005.2, C1006.2, R1002.2, U1001.6 (GND), U1001.7 (EP); also elsewhere on the board

Parts of its further copies:
C1101, C1102, C1104, C1105, C1106: 4u7; C_0402
C1103: 22p; C_0402
L1101: 78438313015; L_Wurth_WE-MAIA-1610; Part Number 78438313015
R1101: 180k; R_0402
R1102: 360k; R_0402
TP1101: 1.5mm; TestPoint_Pad_D1.5mm
U1101: TPS62290TDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS62290TDRVRQ1

Connections of its further copies:
+0V9_2: C1103.1, C1104.1, C1105.1, C1106.1, L1101.2, R1101.1, TP1101.1 (1_1); also elsewhere on the board
+3V3: C1101.1, C1102.1, U1101.2 (MODE), U1101.4 (EN), U1101.5 (VIN); also elsewhere on the board
/Power/Ethernet Power/0V9_2 Buck Converter/FB: C1103.2, R1101.2, R1102.1, U1101.3 (FB)
/Power/Ethernet Power/0V9_2 Buck Converter/SW: L1101.1, U1101.1 (SW)
GND1: C1101.2, C1102.2, C1104.2, C1105.2, C1106.2, R1102.2, U1101.6 (GND), U1101.7 (EP); also elsewhere on the board

Notes on the sheet:
0V9 Regulator
Use high quality, low ESR (<50mΩ) capacitors such as GRM155R61A475ME02

Schematic: 1v2_buck_converter.kicad_sch

Parts:
C801, C802, C804, C805, C806: 4u7; C_0402
C803: 22p; C_0402
L801: 78438313015; L_Wurth_WE-MAIA-1610; Part Number 78438313015
R801, R802: 180k; R_0402
TP801: 1.5mm; TestPoint_Pad_D1.5mm
U801: TPS62290TDRVRQ1; SON65P200X200X80-7N; Mouser Part Number 595-TPS62290TDRVRQ1

Connections:
+1V2: C803.1, C804.1, C805.1, C806.1, L801.2, R801.1, TP801.1 (1_1), U801.2 (MODE); also elsewhere on the board
+3V3: C801.1, C802.1, U801.4 (EN), U801.5 (VIN); also elsewhere on the board
/Power/Ethernet Power/1V2 Buck Converter/FB: C803.2, R801.2, R802.1, U801.3 (FB)
/Power/Ethernet Power/1V2 Buck Converter/SW: L801.1, U801.1 (SW)
GND1: C801.2, C802.2, C804.2, C805.2, C806.2, R802.2, U801.6 (GND), U801.7 (EP); also elsewhere on the board

Notes on the sheet:
1V2 Regulator
Use high quality, low ESR (<50mΩ) capacitors such as GRM155R61A475ME02
